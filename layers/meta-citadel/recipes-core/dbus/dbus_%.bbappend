PACKAGECONFIG_append = " user-session"

EXTRA_OECONF_append = " --with-system-socket=/run/dbus/system_bus_socket"
